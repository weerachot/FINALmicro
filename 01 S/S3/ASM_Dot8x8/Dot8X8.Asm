
T2CON		EQU	0C8H
RCAP2L		EQU	0CAH 
RCAP2H		EQU	0CBH
SW0		EQU	P1.0
SW1		EQU	P1.1
SW2		EQU	P1.2
SW3		EQU	P1.3

DataBuffer	EQU	20H	;8Byte Buffer

MxBoard_DIN	EQU	P3.4
MxBoard_CS	EQU	P3.3
MxBoard_CLK	EQU	P3.2

PortO_LEDGreen	EQU	P3.7	
	
		ORG	0000H	
		JMP	0100H
	
		ORG	0100H
		MOV	SP,#3FH
		CLR	EA	
		CALL	Delay_250M	
		CALL	Initial_Max7219	
		
Main_Loop:
		JNB	SW0,SWB0
		JNB	SW1,SWB1
		JNB	SW2,SWB2
		JNB	SW3,SWB3
		
		JMP	Main_Loop

SWB0:
		MOV	DPTR,#EM0	
		CALL	Send_2_Dot
		JMP	Main_Loop
SWB1:	
		MOV	DPTR,#EM1	
		CALL	Send_2_Dot
		JMP	Main_Loop
SWB2:	
		MOV	DPTR,#EM2	
		CALL	Send_2_Dot
		JMP	Main_Loop
SWB3:	
		MOV	DPTR,#EM3
		CALL	Send_2_Dot
		JMP	Main_Loop

$INCLUDE (myDelay.A51)
$INCLUDE (mySerial.A51)
$INCLUDE (myMaxDot.A51)
	
EM0:		DB	03CH,042H,0A5H,081H,0A5H,099H,042H,03CH
EM1:		DB	03CH,042H,0A5H,081H,0BDH,081H,042H,03CH
EM2:		DB	03CH,042H,0A5H,081H,099H,0A5H,042H,03CH
EM3:		DB	03CH,042H,0A5H,081H,099H,099H,042H,03CH
		
		END
