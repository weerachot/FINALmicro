
T2CON		EQU	0C8H
RCAP2L		EQU	0CAH 
RCAP2H		EQU	0CBH 
PORTSEG		EQU	P2

DataBuffer	EQU	20H	;8Byte Buffer

MxBoard_DIN	EQU	P1.0
MxBoard_CS	EQU	P1.1
MxBoard_CLK	EQU	P1.2

PortO_LEDGreen	EQU	P3.7	
	
		ORG	0000H	
		JMP	0100H
	
		ORG	0100H
		MOV	SP,#3FH
		CLR	EA	
		CALL	Delay_250M	
		CALL	Initial_Max7219	
		CALL	Initial_Serial
		
Main_Loop:
		CLR	C
		CALL	RX_BYTE
		;INC	A
S0:
		CJNE	A,#'0',S1
		MOV	DPTR,#TB_00
		CALL	Send_2_Dot
		MOV	A,#03FH
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
S1:
		CJNE	A,#'1',S2
		MOV	DPTR,#TB_01
		CALL	Send_2_Dot
		MOV	A,#006H
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
S2:
		CJNE	A,#'2',S3
		MOV	DPTR,#TB_02
		CALL	Send_2_Dot
		MOV	A,#05BH
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
S3:
		CJNE	A,#'3',S4
		MOV	DPTR,#TB_03
		CALL	Send_2_Dot
		MOV	A,#04FH
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
S4:
		CJNE	A,#'4',S5
		MOV	DPTR,#TB_04
		CALL	Send_2_Dot
		MOV	A,#066H
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
S5:
		CJNE	A,#'5',S6
		MOV	DPTR,#TB_05
		CALL	Send_2_Dot
		MOV	A,#06DH
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
S6:
		CJNE	A,#'6',S7
		MOV	DPTR,#TB_06
		CALL	Send_2_Dot
		MOV	A,#07DH
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
S7:
		CJNE	A,#'7',S8
		MOV	DPTR,#TB_07
		CALL	Send_2_Dot
		MOV	A,#007H
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
S8:
		CJNE	A,#'8',S9
		MOV	DPTR,#TB_08
		CALL	Send_2_Dot
		MOV	A,#07FH
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
S9:
		CJNE	A,#'9',SA
		MOV	DPTR,#TB_09
		CALL	Send_2_Dot
		MOV	A,#06FH
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
SA:
		CJNE	A,#'A',SB
		MOV	DPTR,#TB_0A
		CALL	Send_2_Dot
		MOV	A,#077H
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
SB:
		CJNE	A,#'B',SC
		MOV	DPTR,#TB_0B
		CALL	Send_2_Dot
		MOV	A,#07CH
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
SC:
		CJNE	A,#'C',SD
		MOV	DPTR,#TB_0C
		CALL	Send_2_Dot
		MOV	A,#039H
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
SD:
		CJNE	A,#'D',SE
		MOV	DPTR,#TB_0D
		CALL	Send_2_Dot
		MOV	A,#05EH
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
SE:
		CJNE	A,#'E',SF
		MOV	DPTR,#TB_0E
		CALL	Send_2_Dot
		MOV	A,#079H
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
SF:
		CJNE	A,#'F',SOO
		MOV	DPTR,#TB_0F
		CALL	Send_2_Dot
		MOV	A,#071H
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop
SOO:
		MOV	DPTR,#SBB
		CALL	Send_2_Dot
		MOV	A,#00H
		CPL	A
		MOV	PORTSEG,A
		JMP	Main_Loop

$INCLUDE (myDelay.A51)
$INCLUDE (mySerial.A51)
$INCLUDE (myMaxDot.A51)


SBB:		DB	000H,000H,000H,000H,000H,000H,000H,000H	
TB_00:		DB	03CH,042H,046H,04AH,052H,062H,042H,03CH
TB_01:		DB	000H,018H,038H,038H,018H,018H,018H,03CH
TB_02:		DB	000H,038H,044H,004H,008H,010H,020H,07CH
TB_03:		DB	000H,01CH,022H,002H,00CH,002H,022H,01CH
TB_04:		DB	000H,00CH,014H,024H,024H,03EH,004H,004H
TB_05:		DB	000H,07CH,040H,040H,038H,004H,044H,038H
TB_06:		DB	000H,00CH,010H,020H,03CH,022H,022H,01CH
TB_07:		DB	000H,07CH,004H,008H,010H,020H,020H,020H
TB_08:		DB	000H,01CH,022H,022H,01CH,022H,022H,01CH
TB_09:		DB	000H,01CH,022H,022H,01EH,002H,004H,018H
TB_0A:		DB	000H,01CH,022H,022H,022H,03EH,022H,022H
TB_0B:		DB	000H,03CH,022H,022H,03CH,022H,022H,03CH
TB_0C:		DB	000H,01CH,022H,020H,020H,020H,022H,01CH
TB_0D:		DB	000H,03CH,022H,022H,022H,022H,022H,03CH
TB_0E:		DB	000H,03EH,022H,020H,038H,020H,022H,03EH
TB_0F:		DB	000H,03EH,020H,020H,038H,020H,020H,020H

		END
